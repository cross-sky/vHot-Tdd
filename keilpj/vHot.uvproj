# Keil uVision project vHot.uvproj, settings and files
target vlcd (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\examples_C\ApplicationLib\inc;..\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group FWlib
    ../FWlib/: STM32-keil.lib
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
  group bsp
    ../examples_C/ApplicationLib/src/bsp/: stm32_ub_led.c stm32f10x_it.c task.c Tsystick.c RTCom2.c adc_filter.c ComInput.c ComInputADC.c relay.c valve.c
    ../examples_C/ApplicationLib/src/util/: Queue.c assert.c except.c
  group user
    ./: main.c
  group Readme
    ../: readme.txt
